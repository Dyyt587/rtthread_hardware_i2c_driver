# Keil uVision project project.uvprojx, settings and files
target rt-thread (6210000::V6.21::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __perf_counter_printf__=rt_kprintf, STM32H750xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __PERF_CNT_USE_RTOS__, __RTTHREAD__, USE_HAL_DRIVER
  c include: rt-thread\components\finsh;rt-thread\components\drivers\spi;rt-thread\components\libc\posix\io\epoll;libraries\HAL_Drivers\drivers\config;applications;rt-thread\components\libc\posix\io\poll;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\HAL_Drivers\drivers;rt-thread\components\drivers\include;rt-thread\components\libc\cplusplus;packages\i2c-tools-latest;rt-thread\components\drivers\include;rt-thread\components\drivers\include;.;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;packages\perf_counter-latest;rt-thread\components\libc\compilers\common\include;packages\i2c-tools-latest\src;packages\CMSIS_5-v5.9.0\CMSIS\Core\Include;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\include;packages\CMSIS_5-v5.9.0\CMSIS\RTOS2\Include;rt-thread\components\drivers\hwcrypto;rt-thread\components\drivers\include;board\port;libraries\HAL_Drivers;rt-thread\components\fal\inc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;board\CubeMX_Config\Core\Inc;rt-thread\components\drivers\spi\sfud\inc;packages\CMSIS_RTOS2-latest;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\ulog;rt-thread\libcpu\arm\cortex-m7;packages\at24cxx-latest;board;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\common
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c at24c_hal.c
    ../../common/: drv_i2c.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group CMSIS-RTOS2
    packages/CMSIS_RTOS2-latest/: os_systick.c cmsis_rtthread.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwcrypto/: hw_crc.c hwcrypto.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nand.c mtd_nor.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/: drv_mpu.c nand_mt29f4g08.c spi_flash_init.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/HAL_Drivers/drivers/: drv_crypto.c drv_gpio.c drv_sdram.c drv_soft_i2c.c drv_spi.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Fal
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
    rt-thread/components/fal/src/: fal_partition.c fal_rtt.c fal.c fal_flash.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c signal.c slab.c thread.c timer.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group perf_counter
    packages/perf_counter-latest/os/: perf_os_patch_rt_thread.c
    packages/perf_counter-latest/: perf_counter.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 6.0.0
